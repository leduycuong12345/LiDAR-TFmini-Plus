<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Simple_Read_Distance.ewp</path>
  </project>
  <batchBuild />
</workspace>
